# Keil uVision project TOUCH.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\USER;..\HARDWARE\TOUCH;..\CMSIS\Include;..\STM32F4xx_StdPeriph_Driver\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LCD;..\HARDWARE\FLASH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c test.c GUI.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: touch.c
  group CORE
    ../CMSIS/Source/arm/: startup_stm32f40_41xxx.s
    ../CMSIS/Source/: system_stm32f4xx.c
  group FWLib
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c
