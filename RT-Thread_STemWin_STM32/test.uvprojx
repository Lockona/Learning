# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,OS_SUPPORT
  c include: .\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\rtthread_nano\3.0.3\components\finsh;.\rtthread_nano\3.0.3\include;.\rtthread_nano\3.0.3\include\libc;.\STemWin\inc;.\STemWin_Task;.\user;.\user\lcd;.\user\TOUCH;.\user\sdio;.\FATFS;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\STemWin\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: board.c main.c
    ./user/lcd/: lcd_driver.c
    ./user/TOUCH/: touch.c
    ./user/sdio/: bsp_sdio_sd.c
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group LIB
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_crc.c stm32f4xx_dma.c
  group rtthread\src
    ./rtthread_nano/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtthread\port
    ./rtthread_nano/3.0.3/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group STemWin
    ./STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor.c
    ./STemWin/Lib/: STemWin_CM4_OS_wc16_ot_ARGB.a
    ./STemWin/OS/: GUI_X_RTthread.c
  group STemWin\MainTask
    ./STemWin_Task/: GUIFont_Create.c ScreenShot.c text.c MainTask.c
  group FatFs
    ./FATFS/: diskio.c ff.c
    ./FATFS/option/: cc936.c
