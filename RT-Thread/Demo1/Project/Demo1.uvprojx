# Keil uVision project Demo1.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Demo1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\User;..\rtthread\3.0.3\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
