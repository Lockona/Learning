# Keil uVision project Fire_F407.uvprojx, settings and files
target Fire_F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire_F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,OS_SUPPORT
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\User\uart;..\..\User\key;..\..\User\led;..\..\STemWin\Config;..\..\STemWin\inc;..\..\STemWin_Task;..\..\User\FATFS;..\..\User\lcd;..\..\User\TOUCH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h
    ../../User/lcd/: lcd_driver.c
    ../../User/TOUCH/: touch.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group STemWIN
    ../../STemWin/Config/: GUIConf.c GUIConf.h LCDConf_FlexColor.c GUIDRV_Template.c
    ../../STemWin/OS/: GUI_X_FreeRTOS.c
    ../../STemWin/Lib/: STemWin_CM4_OS_wc16_ot_ARGB.a
  group STemWIN/Task
    ../../STemWin_Task/: MainTask.c
  group DOC
    ../../: 必读说明.txt
